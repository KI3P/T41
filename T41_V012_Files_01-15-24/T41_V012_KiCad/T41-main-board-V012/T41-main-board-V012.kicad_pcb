# Repository KI3P/T41

## KiCad design T41_V012_Files_01-15-24/T41_V012_KiCad/T41-main-board-V012/T41-main-board-V012.kicad_pcb

Board: 4 copper layers, 100.0 x 100.0 mm, 103 parts (10 on the bottom side), 90 nets.

Parts:
C1, C6, C7: 470uF 25V; CP_Radial_D10.0mm_P5.00mm
C2, C3, C8, C9, C10, C11, C13, C14, C16, C19, C20, C23, C24, C26, C31: 0.1uF 50V; C_1206_3216Metric
C4, C12, C15, C17, C18, C21, C22, C25, C27, C30, C33: 10uF 16V; C_1206_3216Metric
C5: 1uF 50V; C_1206_3216Metric
C28, C29: 2.2uF 16V; C_1206_3216Metric
C32, C34: 2.2nF; C_1206_3216Metric
D1: 1N4007; D_SMA
D2, D3, D4: LED; D_1206_3216Metric
D5: 10V; D_SMA
H1, H2, H3, H4: MountingHole_3mm_Pad
H5, H6: MountingHole_4.3mm_M4_DIN965_Pad
J1: +12V; PinHeader_1x02_P5.08mm_Vertical
J2: Fan1; PinHeader_1x02_P2.54mm_Vertical
J3: Acc; IDC-Header_2x04_P2.54mm_Vertical
J4: 12-13.8V; PinHeader_1x02_P5.08mm_Vertical
J5: Front Panel; IDC-Header_2x05_P2.54mm_Vertical
J6: RF CONTROL; IDC-Header_2x05_P2.54mm_Vertical
J7: Display; IDC-Header_2x05_P2.54mm_Vertical
J8: Display Voltage; PinHeader_1x03_P2.54mm_Vertical
J9: Keys/PTT; IDC-Header_2x03_P2.54mm_Vertical
J10, J18: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J11: ENCODER; IDC-Header_2x05_P2.54mm_Vertical
J12: BANDS; IDC-Header_2x05_P2.54mm_Vertical
J13: Header; PinHeader_1x02_P2.54mm_Vertical
J14: Rec_Out; Jack_3.5mm_STX-3081_Horizontal
J15: Rec_In; Jack_3.5mm_STX-3081_Horizontal
J16: Mic_In; Jack_3.5mm_STX-3081_Horizontal
J17: Ex_Out; Jack_3.5mm_STX-3081_Horizontal
J19, J20, J21: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J22: Header; PinHeader_1x03_P2.54mm_Vertical
J23: Ethernet; IDC-Header_2x03_P2.54mm_Vertical
J24: USBHost; IDC-Header_2x03_P2.54mm_Vertical
L1, L2, L3: 10uH 20%; L_Bourns-SRN6028
Q1: IRF4905; TO-220-3_Vertical
Q2, Q3: 2N7000; TO-92_Inline
R1, R2: 10K; R_1206_3216Metric
R3, R8, R9, R14: 1K; R_1206_3216Metric
R4, R5: 220R; R_1206_3216Metric
R6, R11, R12: 100R; R_1206_3216Metric
R7: 2K2; R_1206_3216Metric
R10, R13: 470R; R_1206_3216Metric
R15: 150R; R_1206_3216Metric
R16: 100k; R_1206_3216Metric
SW1: ON-OFF BUTTON; PinHeader_1x02_P2.54mm_Vertical
TP1, TP2: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U1, U9: LM7805CT; TO-220-3_Vertical
U2: AP7384-50V; TO-92_Inline_Wide
U3, U10: LM1117T-3.3; TO-220-3_Vertical
U4: ATtiny85-20S; DIP-8_W7.62mm_Socket
U5: PCM5102; TSSOP-20_4.4x6.5mm_P0.65mm
U6: PCM1808PW; TSSOP-14_4.4x5mm_P0.65mm
U8: Teensy4.1; Teensy41

Connections:
+3V3: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C24.1, C25.1, D2.2 (A), J5.3, J5.4, J8.3, J11.3, J11.4, L3.2, R7.2, TP2.1, U5.1 (CPVDD), U5.8 (AVDD), U5.20 (DVDD), U6.4 (VDD)
+5V: C11.1, C22.1, C23.1, D3.2 (A), J3.7, J8.1, L1.2, TP1.1, U6.3 (VCC), U8.48 (VIN)
+12P: J4.2, L2.2
+12V: C3.1, C6.1, C31.1, J1.2, J2.1, Q1.2 (D), R15.2, U1.1 (VI), U3.3 (VI), U9.1 (VI), U10.3 (VI)
/A21: J3.4, U8.32 (40_A16)
/A22: J3.6, U8.33 (41_A17)
/ADC_IN: U6.9 (DOUT), U8.8 (6_OUT1D)
/BAND0 (80m): J12.1, U8.22 (30_CRX3)
/BAND1 (40m): J12.2, U8.23 (31_CTX3)
/BAND2 (20m): J12.3, U8.20 (28_RX7)
/BAND3 (15m): J12.4, U8.21 (29_TX7)
/BCK: R11.1, U5.13 (BCK), U8.43 (21_A7_RX5_BCLK1)
/BEGIN TEENSY SHUTDOWN: U4.6 (PB1), U8.2 (0_RX1_CRX2_CS1)
/CLK: R6.1, U8.45 (23_A9_CRX1_MCLK1)
/CW on/off: J6.7, U8.25 (33_MCLK2)
/Cal: J6.10, U8.30 (38_CS1_IN1)
/C/S: J7.6, U8.12 (10_CS_MQSR)
/D+: J24.3, U8.57 (D+)
/D-: J24.6, U8.56 (D-)
/DAUDIO_OUT: U5.14 (DIN), U8.24 (32_OUT1B)
/FOR: J12.6, U8.18 (26_A12_MOSI1)
/INT1: J5.6, U8.36 (14_A0_TX3_SPDIF_OUT)
/INT2: J5.8, U8.37 (15_A1_RX3_SPDIF_IN)
/Key1 in: J3.3, J9.6, U8.28 (36_CS)
/Key2 in: J3.1, J9.4, U8.27 (35_TX8)
/LED: J23.3, U8.61 (LED)
/LRCK: R12.1, U5.15 (LRCK), U8.42 (20_A6_TX5_LRCLK1)
/MISO: R4.2, U8.14 (12_MISO_MQSL)
/MOSI: R5.1, U8.13 (11_MOSI_CTX1)
/Matrix: J5.9, U8.31 (39_MISO1_OUT1A)
/PTT in: J3.5, J9.3, J16.R, U8.29 (37_CS)
/R+: J23.5, U8.60 (R+)
/R-: J23.6, U8.65 (R-)
/REF: J12.8, U8.19 (27_A13_SCK1)
/RXTX: D4.2 (A), J6.9, J10.1, J12.10, U8.44 (22_A8_CTX1)
/SCL: J6.1, J18.2, U8.41 (19_A5_SCL)
/SCL1: J5.5, U8.38 (16_A2_RX4_SCL1)
/SCL2: J12.7, U8.16 (24_A10_TX6_SCL2)
/SCLK: J7.3, U8.35 (13_SCK_LED)
/SDA: J6.3, J18.1, U8.40 (18_A4_SDA)
/SDA1: J5.7, U8.39 (17_A3_TX4_SDA1)
/SDA2: J12.5, U8.17 (25_A11_RX6_SDA2)
/T+: J23.2, U8.63 (T+)
/T-: J23.1, U8.62 (T-)
/TEENSY SHUTDOWN COMPLETE: U4.7 (PB2), U8.3 (1_TX1_CTX2_MISO1)
/Xmit Mode: J6.6, U8.26 (34_RX8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C31.2, C32.1, C34.2, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.1, J2.2, J3.8, J4.1, J5.1, J5.2, J6.2, J6.4, J6.5, J7.9, J7.10, J9.1, J10.2, J11.1, J11.2, J12.9, J14.S, J15.S, J19.1, J20.1, J21.1, J23.4, J24.4, Q2.1 (S), Q3.1 (S), R2.2, R3.2, R8.1, R9.1, R14.1, R16.2, U1.2 (GND), U2.2 (GND), U3.1 (GND), U4.4 (GND), U5.3 (CPGND), U5.9 (AGND), U5.10 (DEMP), U5.11 (FLT), U5.12 (SCK), U5.16 (FMT), U5.19 (DGND), U6.2 (AGND)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
unnamed: C30.1, C32.2, R10.1
unnamed: C30.2, J14.R
unnamed: C33.1, C34.1, R13.1
unnamed: C33.2, J14.T
unnamed: D1.2 (A), D5.1 (K), L2.1, Q1.3 (S), R1.1
unnamed: C5.1, D1.1 (K), U2.3 (VI)
unnamed: D2.1 (K), R8.2
unnamed: D3.1 (K), R9.2
unnamed: D4.1 (K), R14.2
unnamed: D5.2 (A), Q1.1 (G), Q2.2 (G), Q3.3 (D), R1.2, R16.1
unnamed: J5.10, U8.46 (3V3)
unnamed: J7.4, R5.2
unnamed: J7.5, R4.1
unnamed: C12.1, C13.1, J7.7, J7.8, J8.2
unnamed: J11.5, U8.4 (2_OUT2)
unnamed: J11.6, U8.6 (4_BCLK2)
unnamed: J11.7, U8.5 (3_LRCLK2)
unnamed: J11.8, U8.7 (5_IN2)
unnamed: J13.1, J16.S
unnamed: J13.2, J16.T
unnamed: J17.T, J22.1
unnamed: J17.S, J22.2
unnamed: J17.R, J22.3
unnamed: J24.5, U8.55 (5V)
unnamed: Q2.3 (D), R15.1
unnamed: Q3.2 (G), R2.1, U4.3 (XTAL2/PB4)
unnamed: C1.1, C2.1, L1.1, U1.3 (VO), U9.3 (VO)
unnamed: C4.1, C9.1, SW1.1, U2.1 (VO), U4.8 (VCC)
unnamed: C10.1, R3.1, SW1.2, U4.2 (XTAL1/PB3)
unnamed: C29.2, U5.4 (CAPM)
unnamed: C29.1, U5.2 (CAPP)
unnamed: C20.1, C21.1, U5.18 (LDOO)
unnamed: R13.2, U5.6 (OUTL)
unnamed: R10.2, U5.7 (OUTR)
unnamed: C28.1, U5.5 (VNEG)
unnamed: R7.1, U5.17 (XSMT)
unnamed: R11.2, U6.8 (BCK)
unnamed: R12.2, U6.7 (LRCK)
unnamed: R6.2, U6.6 (SCKI)
unnamed: J15.R, U6.13 (VIN_L)
unnamed: J15.T, U6.14 (VIN_R)
unnamed: C26.1, C27.1, U6.1 (VREF)
unnamed: C7.1, C8.1, L3.1, U3.2 (VO), U10.2 (VO)

## Commit log

2024-01-26 Moved voltage regulator on main board so no interference with Teensy audio hat
